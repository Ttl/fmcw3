# Repository Ttl/fmcw3 (continued)

## KiCad design hardware/fmcw3.kicad_pcb (continued)

Parts:
C124, C125, C140, C141, C142, C143, C144, C145, C146, C147, C148, C149: DNP; C_0402b
C126, C127: 2.2n; C_0402b
C128, C129, C130, C131: 10n; C_0402b
C132, C133, C138, C139, C150, C151: 100n; C_0402b
C134, C135, C136, C137: 10p; C_0402b
C173: DNP; C_0805b
L8, L9, L10, L11: 2.2u; C_0805b
R55, R56, R57, R58: 550; R_0402b
R59, R60, R61, R62: 8.2k; R_0402b
R63, R64, R65, R66, R67, R68, R74, R75, R76, R77, R78, R86: DNP; R_0402b
R87, R89, R90, R94: 0; R_0402b
U34, U35: ADA4940-2; VFQFN-24

Connections:
/3V3A: C138.1, C139.1, C150.1, C151.1, C173.1, U34.3 (+VS), U34.4 (+VS), U34.9 (+VS), U34.10 (+VS), U34.14 (~PD), U34.20 (~PD), U35.3 (+VS), U35.4 (+VS), U35.9 (+VS), U35.10 (+VS), U35.14 (~PD), U35.20 (~PD); also elsewhere on the board
/ADC1+: R94.1, U35.12 (+OUT); also elsewhere on the board
/ADC1-: R90.2, U35.13 (-OUT); also elsewhere on the board
/ADC2+: R89.1, U35.18 (+OUT); also elsewhere on the board
/ADC2-: R87.2, U35.19 (-OUT); also elsewhere on the board
/ADC_VCM1: C133.1, C148.1, R67.2, R68.1, U34.17 (VCOM), U35.17 (VCOM); also elsewhere on the board
/ADC_VCM2: C132.1, C149.1, R74.2, R75.1, U34.11 (VCOM), U35.11 (VCOM); also elsewhere on the board
/if/IF1+: C124.1, L8.1; also elsewhere on the board
/if/IF1-: C124.2, L9.1; also elsewhere on the board
/if/IF2+: C125.2, L11.1; also elsewhere on the board
/if/IF2-: C125.1, L10.1; also elsewhere on the board
GND: C132.2, C133.2, C138.2, C139.2, C148.2, C149.2, C150.2, C151.2, C173.2, U34.15 (-VS), U34.16 (-VS), U34.21 (-VS), U34.22 (-VS), U34.PAD, U35.15 (-VS), U35.16 (-VS), U35.21 (-VS), U35.22 (-VS), U35.PAD; also elsewhere on the board
unnamed: C126.1, C128.2, L8.2
unnamed: C126.2, C129.2, L9.2
unnamed: C127.1, C130.2, L10.2
unnamed: C127.2, C131.2, L11.2
unnamed: C128.1, R55.2
unnamed: C129.1, R56.2
unnamed: C130.1, R57.2
unnamed: C131.1, R58.2
unnamed: C134.1, R60.1, U34.8 (+FB)
unnamed: C134.2, R56.1, R60.2, U34.7 (-IN)
unnamed: C135.1, R55.1, R59.1, U34.6 (+IN)
unnamed: C135.2, R59.2, U34.5 (-FB)
unnamed: C136.1, R62.1, U34.2 (+FB)
unnamed: C136.2, R58.1, R62.2, U34.1 (-IN)
unnamed: C137.1, R57.1, R61.1, U34.24 (+IN)
unnamed: C137.2, R61.2, U34.23 (-FB)
unnamed: C140.1, C144.2, R63.2
unnamed: C140.2, R87.1, U34.19 (-OUT)
unnamed: C141.1, C145.2, R64.1
unnamed: C141.2, R89.2, U34.18 (+OUT)
unnamed: C142.1, C146.2, R65.2
unnamed: C142.2, R90.1, U34.13 (-OUT)
unnamed: C143.1, C147.2, R66.1
unnamed: C143.2, R94.2, U34.12 (+OUT)
unnamed: C144.1, R67.1, R76.2, U35.24 (+IN)
unnamed: C145.1, R68.2, R77.2, U35.1 (-IN)
unnamed: C146.1, R74.1, R78.2, U35.6 (+IN)
unnamed: C147.1, R75.2, R86.2, U35.7 (-IN)
unnamed: R63.1, R76.1, U35.23 (-FB)
unnamed: R64.2, R77.1, U35.2 (+FB)
unnamed: R65.1, R78.1, U35.5 (-FB)
unnamed: R66.2, R86.1, U35.8 (+FB)

Parts:
C152, C153, C154, C158, C159, C160, C161, C207, C210, C211, C212: 100n; C_0402b
C155, C156, C157: 4.7u; C_0603b
C208, C209: 15p; C_0402b
FB12, FB14: BLM18PG181SN1D; C_0603b
R71: 12k; R_0402b
R72: 1k; R_0402b
R73, R83: 10k; R_0402b
R79: 2.2k; R_0402b
R80, R81: 0; R_0402b
R82: 4.7k; R_0402b
R84, R85, R88: 33; R_0402b
U31: USB-MICRO; USB_MICRO
U32: 93LC46B; SOT-23-6
U33: FT2232H; LQFP-64_10x10mm_P0.5mm
Y1: ABM10-167-12.000MHZ-T3; ABM10

Connections:
/3V3D: C158.1, C159.1, C160.1, C161.1, C207.1, C210.1, FB12.1, FB14.1, R72.2, R73.1, U32.6 (VCC), U33.20 (VCCIO), U33.31 (VCCIO), U33.42 (VCCIO), U33.50 (VREGIN), U33.56 (VCCIO); also elsewhere on the board
/fpga/CLKOUT: U33.32 (ACBUS5); also elsewhere on the board
/fpga/FT_D0: U33.16 (ABUS0); also elsewhere on the board
/fpga/FT_D1: U33.17 (ABUS1); also elsewhere on the board
/fpga/FT_D2: U33.18 (ABUS2); also elsewhere on the board
/fpga/FT_D3: U33.19 (ABUS3); also elsewhere on the board
/fpga/FT_D4: U33.21 (ABUS4); also elsewhere on the board
/fpga/FT_D5: U33.22 (ABUS5); also elsewhere on the board
/fpga/FT_D6: U33.23 (ABUS6); also elsewhere on the board
/fpga/FT_D7: U33.24 (ABUS7); also elsewhere on the board
/fpga/FT_SUSPEND: U33.36 (SUSPEND#); also elsewhere on the board
/fpga/OE#: U33.33 (ACBUS6); also elsewhere on the board
/fpga/RD#: U33.28 (ACBUS2); also elsewhere on the board
/fpga/RXF#: U33.26 (ACBUS0); also elsewhere on the board
/fpga/SIWUA: U33.30 (ACBUS4); also elsewhere on the board
/fpga/TCK: R84.1; also elsewhere on the board
/fpga/TDI: R88.1; also elsewhere on the board
/fpga/TDO: U33.40 (BDBUS2); also elsewhere on the board
/fpga/TMS: R85.1; also elsewhere on the board
/fpga/TXE#: U33.27 (ACBUS1); also elsewhere on the board
/fpga/WR: U33.29 (ACBUS3); also elsewhere on the board
/fpga/usb/1V8: C152.1, C153.1, C154.1, C156.1, U33.12 (VCORE), U33.37 (VCORE), U33.49 (VREGOUT), U33.64 (VCORE)
/fpga/usb/DO: R73.2, R79.1, U32.1 (DO)
/fpga/usb/EECLK: U32.4 (CLK), U33.62 (EECLK)
/fpga/usb/EECS: U32.5 (CS), U33.63 (EECS)
/fpga/usb/EEDATA: R79.2, U32.3 (DI), U33.61 (EEDATA)
/fpga/usb/USBDM: R80.2, U31.2 (D-)
/fpga/usb/USBDP: R81.2, U31.3 (D+)
/fpga/usb/USB_5V: R82.1, U31.1 (VCC)
GND: C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, R71.2, R83.2, U31.5 (GND), U32.2 (VSS), U33.1 (GND), U33.5 (GND), U33.10 (AGND), U33.11 (GND), U33.13 (TEST), U33.15 (GND), U33.25 (GND), U33.35 (GND), U33.47 (GND), U33.51 (GND); also elsewhere on the board
unnamed: C155.1, C211.1, FB12.2, U33.4 (VPHY)
unnamed: C157.1, C212.1, FB14.2, U33.9 (VPLL)
unnamed: C208.1, U33.2 (OSCI), Y1.1
unnamed: C209.1, U33.3 (OSCO), Y1.3
unnamed: R71.1, U33.6 (REF)
unnamed: R72.1, U33.14 (RESET#)
unnamed: R80.1, U33.7 (DM)
unnamed: R81.1, U33.8 (DP)
unnamed: R82.2, R83.1, U33.59 (BCBUS7)
unnamed: R84.2, U33.38 (BDBUS0)
unnamed: R85.2, U33.41 (BDBUS3)
unnamed: R88.2, U33.39 (BDBUS1)

Parts:
C19, C20, C217, C218, C222, C249: 1u; C_0603b
C22, C31, C216, C220: 2.2u; C_0603b
C23, C24, C25, C27, C30, C219, C221, C223, C224, C225: 100n; C_0402b
C163, C164, C165, C166, C167, C168: 100p; C_0402b
C248: 10u; C_0805b
R20, R91, R93: 0; R_0402b
R21: 22; R_0402b
R92: DNP; R_0402b
R97, R98, R99, R100: 49.9; R_0402b
U8: LTC2292; QFN-64-1EP_9x9mm_P0.5mm_EP7.35x7.35mm
U39: LP5907-3.0; SOT-23-5

Connections:
/3V3D: C25.1, C225.1, U8.32 (OVDD), U8.49 (OVDD); also elsewhere on the board
/3V6: C248.1, U39.1 (IN), U39.3 (EN); also elsewhere on the board
/ADC1+: R100.2; also elsewhere on the board
/ADC1-: R98.2; also elsewhere on the board
/ADC2+: R99.2; also elsewhere on the board
/ADC2-: R97.2; also elsewhere on the board
/ADC_REF: R21.2, U8.8 (CLKA), U8.9 (CLKB); also elsewhere on the board
/ADC_VCM1: C216.1, C219.1, U8.61 (VCMA); also elsewhere on the board
/ADC_VCM2: C30.1, C31.1, U8.20 (VCMB); also elsewhere on the board
/fpga/ADC_OE1: U8.58 (~OEA); also elsewhere on the board
/fpga/ADC_OE2: U8.23 (~OEB); also elsewhere on the board
/fpga/ADC_SHDN1: U8.59 (SHDNA); also elsewhere on the board
/fpga/ADC_SHDN2: U8.22 (SHDNB); also elsewhere on the board
/fpga/D0: U8.43 (DA0); also elsewhere on the board
/fpga/D1: U8.44 (DA1); also elsewhere on the board
/fpga/D2: U8.45 (DA2); also elsewhere on the board
/fpga/D3: U8.46 (DA3); also elsewhere on the board
/fpga/D4: U8.47 (DA4); also elsewhere on the board
/fpga/D5: U8.48 (DA5); also elsewhere on the board
/fpga/D6: U8.51 (DA6); also elsewhere on the board
/fpga/D7: U8.52 (DA7); also elsewhere on the board
/fpga/D8: U8.53 (DA8); also elsewhere on the board
/fpga/D9: U8.54 (DA9); also elsewhere on the board
/fpga/D10: U8.55 (DA10); also elsewhere on the board
/fpga/D11: U8.56 (DA11); also elsewhere on the board
/fpga/OF1: U8.57 (OFA); also elsewhere on the board
/fpga/OF2: U8.40 (OFB); also elsewhere on the board
/fpga/adc/3V0: C24.1, C27.1, C222.1, C223.1, C224.1, C249.1, R20.2, R91.1, R93.2, U8.7 (VDD), U8.10 (VDD), U8.18 (VDD), U8.63 (VDD), U39.5 (OUT)
/fpga/adc/REFHA: C217.1, C220.1, C221.1, U8.3 (REFHA), U8.4 (REFHA)
/fpga/adc/REFHB: C19.1, C22.1, C23.1, U8.11 (REFLB), U8.12 (REFLB)
/fpga/adc/REFLA: C218.1, C220.2, C221.2, U8.5 (REFLA), U8.6 (REFLA)
/fpga/adc/REFLB: C20.1, C22.2, C23.2, U8.13 (REFHB), U8.14 (REFHB)
GND: C19.2, C20.2, C24.2, C25.2, C27.2, C30.2, C31.2, C163.1, C165.2, C166.1, C168.2, C216.2, C217.2, C218.2, C219.2, C222.2, C223.2, C224.2, C225.2, C248.2, C249.2, R92.2, U8.17 (GND), U8.31 (OGND), U8.50 (OGND), U8.64 (GND), U8.65 (PAD), U39.2 (GND); also elsewhere on the board
unnamed: C163.2, C164.1, R97.1, U8.1 (AINA+)
unnamed: C164.2, C165.1, R99.1, U8.2 (AINA-)
unnamed: C166.2, C167.1, R98.1, U8.15 (AINB-)
unnamed: C167.2, C168.1, R100.1, U8.16 (AINB+)
unnamed: R20.1, U8.19 (SENSEB)
unnamed: R21.1, U8.21 (MUX)
unnamed: R91.2, R92.1, U8.60 (MODE)
unnamed: R93.1, U8.62 (SENSEA)

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
Board: 4 copper layers, 101.8 x 46.8 mm, 429 parts (114 on the bottom side), 267 nets.

File hardware/Clean_BOM.xlsx (part):

Id | Designator | Package | PCB Orientation | Qty | Designation | Type | Note | Check footprint | Supplier | SPN | Manufacturer | MFP | Datasheet | [Reflow] max temp [C] | [Reflow] max duration [s] | Ordered | Arrived | In bottom? | In top? | Is SPN? | SPN count
48 | C10,C127,C126 | C_0402b | - | 3 | 2.2n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRX7R9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 | 311-1678-1-ND | Yageo | CC0402JRX7R9BB222 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1678-1-ND | 1
29 | C114,C3,C5,C7,C8,C11,C44,C36,C109,C111,C112,C113,C53,C134,C135,C136,C137,C110 | C_0402b | - | 18 | 10p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1014-1-ND | Yageo | CC0402JRNPO9BN100 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1014-1-ND | 1
45 | C14 | C_0402b | - | 1 | 51p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1672-1-ND | Yageo | CC0402JRNPO9BN510 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1672-1-ND | 1
20 | C156,C155,C157 | C_0603b | - | 3 | 4.7u_0603 |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0603KRX5R6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 | 311-1455-1-ND | Yageo | CC0603KRX5R6BB475 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1455-1-ND | 311-1455-1-ND | 1
19 | C170,C171,C205,C199,C187,C189,C190,C191,C192,C193,C198,C200,C201,C202,C203,C204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 | C_0402b | - | 19 | 470n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX5R6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 | 311-1689-1-ND | Yageo | CC0402KRX5R6BB474 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1689-1-ND | #N/A | 1
10 | C175,C174,C125,C124,C140,C141,C142,C143,C144,C147,C148,C149,C145,C146 | C_0402b | - | 14 | DNP |  |  | Yes | - | - |  |  |  |  |  |  |  | - | - | 0
8 | C176,C43,C159,C153,C158,C152,C154,C161,C160,C2,C4,C6,C9,C23,C15,C207,C24,C25,C2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 | C_0402b | - | 51 | 100n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX7R7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 | 311-1338-1-ND | Yageo | CC0402KRX7R7BB104 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1338-1-ND | 311-1338-1-ND | 1
3 | C179,C206,C13,C28,C96,C63,C65,C66,C16,C95,C97,C99,C131,C129,C128,C130 | C_0402b | - | 16 | 10n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX7R9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 | 311-1349-1-ND | Yageo | CC0402KRX7R9BB103 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1349-1-ND | 311-1349-1-ND | 1
4 | C180,C213,C165,C163,C164,C168,C167,C166,C34,C33,C40,C68,C41,C119,C118,C117 | C_0402b | - | 16 | 100p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1024-1-ND | Yageo | CC0402JRNPO9BN101 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1024-1-ND | 1
36 | C181 | C_1210 | - | 1 | 100u |  |  | Yes | https://www.digikey.com/product-detail/en/samsung-electro-me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 | 1276-1092-1-ND | Samsung Electro-Mechanics | CL32A107MQVNNNE | Datasheets\19-CL32A107MQVNNNE.pdf | 260 +/- 5 | 30 | 43621 | 43626 | #N/A | 1276-1092-1-ND | 1
35 | C182,C184,C196 | C_1206 | - | 3 | 47u |  |  | Yes | https://www.digikey.com/product-detail/en/samsung-electro-me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 | 1276-3064-1-ND | Samsung Electro-Mechanics | CL31A476MQHNNWE | Datasheets\CL_Series_MLCC_ds.pdf | 260 +0/-5 | 10 | 43621 | 43626 | #N/A | 1276-3064-1-ND | 1
26 | C185,C188,C195,C194,C186,C183 | C_0805b | - | 6 | 4.7u_0805 |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0805KKX5R6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 | 311-1863-1-ND | Yageo | CC0805KKX5R6BB475 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1863-1-ND | 311-1863-1-ND | 1
55 | C19,C249,C20,C222,C218,C12,C217,C89 | C_0603b | - | 8 | 1u | Verify 12+ V rating -> yes |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0603KRX5R7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 | 311-1444-1-ND | Yageo | CC0603KRX5R7BB105 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1444-1-ND | 311-1444-1-ND | 1
44 | C208,C209 | C_0402b | - | 2 | 15p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1017-1-ND | Yageo | CC0402JRNPO9BN150 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1017-1-ND | 1
2 | C215,C214,C177,C178,C173,C172,C169,C81,C72,C1,C71,C103,C104,C105,C107 | C_0805b | - | 15 | DNP |  |  | Yes | - | - |  |  |  |  |  |  |  | - | - | 0
54 | C22,C31,C39,C220,C216 | C_0603b | - | 5 | 2.2u_0603 |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0603KRX5R6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 | 311-1451-1-ND | Yageo | CC0603KRX5R6BB225 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1451-1-ND | 311-1451-1-ND | 1
46 | C29,C69 | C_0402b | - | 2 | 68p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1340-1-ND | Yageo | CC0402JRNPO9BN680 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1340-1-ND | 311-1340-1-ND | 1
42 | C46,C42,C52,C55 | C_0402b | - | 4 | 18p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1415-1-ND | Yageo | CC0402JRNPO9BN180 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1415-1-ND | 1
43 | C48,C57 | C_0402b | - | 2 | 0.5p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402CRNPO9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 | 311-1001-1-ND | Yageo | CC0402CRNPO9BNR50 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1001-1-ND | 1
30 | C54,C59,C50,C51,C45,C47,C56,C37,C35 | C_0603b | - | 9 | DNP |  |  | Yes | - | - |  |  |  |  |  |  |  | - | - | 0
50 | C67 | C_0402b | - | 1 | 39p |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402JRNPO9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 | 311-1009-1-ND | Yageo | CC0402JRNPO9BN390 | Datasheets\UPY-GP_NP0_16V-to-50V_16.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | #N/A | 311-1009-1-ND | 1
49 | C73 | C_0402b | - | 1 | 15n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX7R8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 | 311-1713-1-ND | Yageo | CC0402KRX7R8BB153 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1713-1-ND | #N/A | 1
51 | C74 | C_0402b | - | 1 | 8.2n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX7R7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 | 311-1041-1-ND | Yageo | CC0402KRX7R7BB822 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1041-1-ND | #N/A | 1
47 | C75 | C_0402b | - | 1 | 4.7n |  |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0402KRX7R8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 | 311-1039-1-ND | Yageo | CC0402KRX7R8BB472 | Datasheets\UPY-GPHC_X7R_6.3V-to-50V_18.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1039-1-ND | #N/A | 1
23 | C83,C84,C162,C86,C85,C82,C80,C79,C78,C77,C76,C248,C106,C70,C93,C87,C94,C98,C100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 | C_0805b | - | 28 | 10u | Verify 12+ V rating -> yes |  | Yes | https://www.digikey.com/product-detail/en/yageo/CC0805KKX5R7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 | 311-1865-1-ND | Yageo | CC0805KKX5R7BB106 | Datasheets\UPY-GPHC_X5R_4V-to-50V_25.pdf | 260 +/- 5 | 10 +/- 0.5 | 43621 | 43626 | 311-1865-1-ND | 311-1865-1-ND | 1
59 | CON1 | DM3BT-DSF-PEJS | - | 1 | SD_Card_DM3BT | SD card holder |  | Yes | https://www.digikey.com/product-detail/en/hirose-electric-co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 | HR1942CT-ND | Hirose Electric Co Ltd | DM3BT-DSF-PEJS | Datasheets\doc_1806131255093.pdf | 250 +0/-20 | 50 | 43621 | 43626 | #N/A | HR1942CT-ND | 1
22 | CON2 | EJ508A | - | 1 | BARREL_JACK | 12 V input |  | Yes | https://www.digikey.com/product-detail/en/mpd-memory-protect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 | EJ508A-ND | MPD (Memory Protection Devices) | EJ508A | Datasheets\EJ508A-datasheet.pdf | N/A | N/A | 43621 | 43626 | #N/A | EJ508A-ND | 1
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
## Code that names these connections

File fpga/fmcw3/fmcw3.srcs/constrs_1/new/fmcw3_constraints.xdc:

create_clock -period 25.000 -name clk -waveform {0.000 12.500} [get_ports clk]
create_clock -period 16.667 -name ft_clkout -waveform {0.000 8.333} [get_ports ft_clkout]

set_property CLOCK_DEDICATED_ROUTE FALSE [get_nets ft_clkout_IBUF]

set_property CFGBVS VCCO [current_design]
set_property CONFIG_VOLTAGE 3.3 [current_design]

set_property IOSTANDARD LVCMOS33 [get_ports {clk}]

set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[11]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[10]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[9]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[8]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[7]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[6]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[5]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[4]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[3]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[2]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_d[0]}]

set_property IOSTANDARD LVCMOS33 [get_ports {adc_shdn[0]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_shdn[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_oe[0]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_oe[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_of[0]}]
set_property IOSTANDARD LVCMOS33 [get_ports {adc_of[1]}]

set_property IOSTANDARD LVCMOS33 [get_ports {mix_enbl}]
set_property IOSTANDARD LVCMOS33 [get_ports {pa_off}]

set_property IOSTANDARD LVCMOS33 [get_ports {adf_muxout}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_le}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_ce}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_le}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_data}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_clk}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_txdata}]
set_property IOSTANDARD LVCMOS33 [get_ports {adf_done}]

set_property IOSTANDARD LVCMOS33 [get_ports {sd_clk}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_cmd}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_data[3]}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_data[2]}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_data[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_data[0]}]
set_property IOSTANDARD LVCMOS33 [get_ports {sd_detect}]

set_property IOSTANDARD LVCMOS33 [get_ports {ext1[5]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext1[4]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext1[3]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext1[2]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext1[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext1[0]}]

set_property IOSTANDARD LVCMOS33 [get_ports {ext2[5]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext2[4]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext2[3]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext2[2]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext2[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ext2[0]}]

set_property IOSTANDARD LVCMOS33 [get_ports {ft_oe}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_rd}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_siwua}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_wr}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_rxf}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_clkout}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_txe}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_suspend}]

set_property IOSTANDARD LVCMOS33 [get_ports {led}]

set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[7]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[6]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[5]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[4]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[3]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[2]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[1]}]
set_property IOSTANDARD LVCMOS33 [get_ports {ft_data[0]}]

set_property IOSTANDARD LVCMOS33 [get_ports {spi_cs}]
set_property IOSTANDARD LVCMOS33 [get_ports {spi_din}]
set_property IOSTANDARD LVCMOS33 [get_ports {spi_dout}]

set_property PACKAGE_PIN N11 [get_ports clk]

set_property PACKAGE_PIN B1 [get_ports adc_shdn[0]]
set_property PACKAGE_PIN N2 [get_ports adc_shdn[1]]
set_property PACKAGE_PIN B2 [get_ports adc_oe[0]]
set_property PACKAGE_PIN P1 [get_ports adc_oe[1]]
set_property PACKAGE_PIN C2 [get_ports adc_of[0]]

set_property PACKAGE_PIN M1 [get_ports adc_of[1]]

set_property PACKAGE_PIN E2 [get_ports adc_d[11]]
set_property PACKAGE_PIN E1 [get_ports adc_d[10]]
set_property PACKAGE_PIN F2 [get_ports adc_d[9]]
set_property PACKAGE_PIN G1 [get_ports adc_d[8]]
set_property PACKAGE_PIN G2 [get_ports adc_d[7]]
set_property PACKAGE_PIN H3 [get_ports adc_d[6]]
set_property PACKAGE_PIN H2 [get_ports adc_d[5]]
set_property PACKAGE_PIN H1 [get_ports adc_d[4]]
set_property PACKAGE_PIN J3 [get_ports adc_d[3]]
set_property PACKAGE_PIN K1 [get_ports adc_d[2]]
set_property PACKAGE_PIN K2 [get_ports adc_d[1]]
set_property PACKAGE_PIN L2 [get_ports adc_d[0]]

set_property PACKAGE_PIN J4 [get_ports mix_enbl]
set_property PACKAGE_PIN T2 [get_ports pa_off]

set_property PACKAGE_PIN K3 [get_ports adf_muxout]
set_property PACKAGE_PIN N1 [get_ports adf_le]
set_property PACKAGE_PIN M2 [get_ports adf_data]
set_property PACKAGE_PIN R1 [get_ports adf_clk]
set_property PACKAGE_PIN P3 [get_ports adf_txdata]
set_property PACKAGE_PIN R3 [get_ports adf_ce]
set_property PACKAGE_PIN T4 [get_ports adf_done]

set_property PACKAGE_PIN N14 [get_ports sd_clk]
set_property PACKAGE_PIN R15 [get_ports sd_cmd]
set_property PACKAGE_PIN M16 [get_ports sd_data[3]]
set_property PACKAGE_PIN N16 [get_ports sd_data[2]]
set_property PACKAGE_PIN P16 [get_ports sd_data[1]]
set_property PACKAGE_PIN R16 [get_ports sd_data[0]]
set_property PACKAGE_PIN H16 [get_ports sd_detect]

set_property PACKAGE_PIN C16 [get_ports ft_suspend]
set_property PACKAGE_PIN D15 [get_ports ft_data[7]]
set_property PACKAGE_PIN D16 [get_ports ft_data[6]]
set_property PACKAGE_PIN E15 [get_ports ft_data[5]]
set_property PACKAGE_PIN E16 [get_ports ft_data[4]]
set_property PACKAGE_PIN F14 [get_ports ft_data[3]]
set_property PACKAGE_PIN G15 [get_ports ft_data[2]]
set_property PACKAGE_PIN G16 [get_ports ft_data[1]]
set_property PACKAGE_PIN F15 [get_ports ft_data[0]]

set_property PACKAGE_PIN B14 [get_ports ft_rd]
set_property PACKAGE_PIN A14 [get_ports ft_wr]
set_property PACKAGE_PIN A13 [get_ports ft_siwua]
set_property PACKAGE_PIN A12 [get_ports ft_oe]
set_property PACKAGE_PIN A15 [get_ports ft_clkout]
set_property PACKAGE_PIN B15 [get_ports ft_txe]
set_property PACKAGE_PIN B16 [get_ports ft_rxf]

set_property PACKAGE_PIN D1 [get_ports led]

set_property PACKAGE_PIN C11 [get_ports ext1[0]]
set_property PACKAGE_PIN B10 [get_ports ext1[1]]
set_property PACKAGE_PIN A9 [get_ports ext1[2]]
set_property PACKAGE_PIN C12 [get_ports ext1[3]]
set_property PACKAGE_PIN B9 [get_ports ext1[4]]
set_property PACKAGE_PIN A8 [get_ports ext1[5]]

set_property PACKAGE_PIN B7 [get_ports ext2[0]]
set_property PACKAGE_PIN A5 [get_ports ext2[1]]
set_property PACKAGE_PIN A4 [get_ports ext2[2]]
set_property PACKAGE_PIN A7 [get_ports ext2[3]]
set_property PACKAGE_PIN B5 [get_ports ext2[4]]
set_property PACKAGE_PIN A3 [get_ports ext2[5]]

set_property PACKAGE_PIN L12 [get_ports spi_cs]
set_property PACKAGE_PIN J14 [get_ports spi_din]
set_property PACKAGE_PIN J13 [get_ports spi_dout]

set_property PULLUP TRUE [get_ports adf_muxout]
set_property PULLUP TRUE [get_ports adf_done]
set_property PULLUP TRUE [get_ports sd_detect]

## Commit log

2017-09-27 Fix FPGA programming resistor connections
    M[2:0] were wired incorrectly when I ordered the board. For programming from SPI
    memory M[2:0] should be "001", but I had them wired backwards as "100". I fixed
    it with one jump wire, but here is a proper fix for anyone looking to reproduce
    the design.
2017-09-28 Update blog post link
2018-02-10 Update kicad: * kicad_pcb from 20170123 to 20171130 (pcbnew from 75cda50 to 5ecfd32) * EESchema from 2 to 4
    fix pin 53 in U33 (remove path in pcb)
2019-07-30 SAR initial commit
2019-08-13 SAR code update
2019-08-26 Fix axis labeling calculations
2019-09-02 Added the rebuilt BOM, the FTDI EEPROM file and all the datasheets
2019-10-21 Backprojection implementation
2019-10-26 Add example data, small code cleanup
2019-11-03 Remove hard coded GPU compute capability
2019-11-03 Rename files
2023-05-05 Openocd changes for the latest version
    Openocd jtagspi protocol changed a long time ago and the new version
    needs a new bitstream to program flash.
