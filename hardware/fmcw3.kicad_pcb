# Repository Ttl/fmcw3

File README.md:

# 6 GHz two RX channel FMCW radar design files.

For more information see: https://hforsten.com/third-version-of-homemade-6-ghz-fmcw-radar.html

## SAR image formation steps:

Compile Tensorflow custom operations in `pc/sar/sar_op`. See `BUILDING` file in
that directory for the instructions.

`pc/sar/process_sweeps.py` is used to slice the correct time from the measurement file.

`./process_sweeps.py <log file> <start time> <end time> [decimation factor]`

It writes `sweeps.p` file with the data in the format the image formation scripts know how to read.
To form the SAR image run `./backprojection_tf.py sweeps.p` or `./omegak_tf.py sweeps.p`.
Some variables related to the image formation can be found on the top of the image formation scripts.

Example data can be downloaded from: https://hforsten.com/fmcw3/parking_lot_sar.log

Use start and end times of 20 and 136 for it. Decimation factor should be 1 or
2 for backprojection and 2 for omega-k.

## KiCad design hardware/fmcw3.kicad_pcb

Schematic: fmcw3.sch

Parts:
C1: DNP; C_0805b
C9, C15, C17: 100n; C_0402b
C12: 1u; C_0603b
C13, C16: 10n; C_0402b
FB1: BLM18PG181SN1D; C_0603b
P5, P7, P8: Conn_01x01; MountingHole_3.2mm_M3_Pad_Via_mod
R3, R8: 470k; R_0402b
R13, R15, R16: 33; R_0402b
U2: LP5907-1.8; SOT-23-5
U4: KT2520K
U5: NC7S04P5X; SOT-353_SC-70-5
U6: NB3N551; DFN-8

Connections:
/1V8_OSC: C12.1, U2.5 (OUT), U4.6 (VDD)
/3V3D: FB1.1; also elsewhere on the board
/3V6: C1.1, C9.1, U2.1 (IN), U2.3 (EN); also elsewhere on the board
/ADC_REF: R15.1; also elsewhere on the board
/ADF_REF: R16.1; also elsewhere on the board
/FPGA_REF: R13.1; also elsewhere on the board
GND: C1.2, C9.2, C12.2, C15.2, C16.2, C17.2, P5.1, P7.1, P8.1, U2.2 (GND), U4.1 (GND), U4.3 (GND), U5.3 (GND), U6.6 (GND), U6.EP; also elsewhere on the board
unnamed: C13.2, U4.4 (OUT)
unnamed: C16.1, R3.1, R8.2
unnamed: R8.1, U5.4, U6.1 (ICLK)
unnamed: R13.2, U6.2 (Q1)
unnamed: R15.2, U6.3 (Q2)
unnamed: R16.2, U6.4 (Q3)

Notes on the sheet:
5V: 200 mA
3V0: 70 mA
2 mA
1V0: 100 mA 1V8: 30 mA 3V0: 170 mA 5V: 200 mA 3.3VA: 540 mA 3.3VD: 100 mA 3V6: 80 mA 10V: 5 mA
3V0: 27 mA 3V3A: 500 mA 5V: 5 mA 10V: 5 mA
3V3A: 5 mA
1V0: 100 mA 1V8: 30 mA 3V6: 80 mA 3V3D: 70 mA
20 mA
Power: TX: 1.65 W LNA: 0.45 W Digital: 0.7 W Mixer: 1.0 W IF: 0.01 W Clock: 0.1 W = 4 W

Schematic: fpga.sch

Parts:
C18, C252: 100n; C_0402b
C170, C171, C187, C189, C190, C191, C192, C193, C197, C198, C199, C200, C201, C202, C203, C204, C205, C250, C251: 470n; C_0402b
C174: DNP; C_0402b
C181: 100u; C_1210_3225Metric
C182, C184, C196: 47u; C_1206_3216Metric
C183, C185, C186, C188, C194, C195: 4.7u; C_0805b
CON1: SD_Card_DM3BT; DM3BT-DSF-PEJS
D6: LED; LED_0603
P3, P4: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical_SMD
P6, P9, P10, P11, P12, P13, P14, P15, P16: Conn_01x01; TP_1.00
Q2: DNP(RE1C002UN); SOT-416
R69, R110: DNP; R_0402b
R70, R114, R115: 0; R_0402b
R109: 240; R_0402b
R111: 1k; R_0402b
R112, R117, R118: 4.7k; R_0402b
R130: 33; R_0402b
SW2: SW_Push; EVP-AWBA2A
U30: XC7A15T-1FTG256C; FTG256
U40: W25Q32JV; DFN-S-8-1EP_6x5mm_P1.27mm

Connections:
/1V0: C181.1, C183.1, C184.1, C186.1, C187.1, C189.1, C191.1, C250.1, U30.E10 (VCCBRAM), U30.F7 (VCCINT), U30.F9 (VCCINT), U30.F11 (VCCBRAM), U30.G6 (VCCINT), U30.H9 (VCCINT), U30.J6 (VCCINT), U30.K9 (VCCINT), U30.L8 (VCCINT); also elsewhere on the board
/1V8: C182.1, C185.1, C188.1, C190.1, C192.1, C193.1, C205.1, U30.G8 (VCCADC_0), U30.G10 (VCCAUX), U30.J10 (VCCAUX), U30.K11 (VCCAUX), U30.L10 (VCCAUX); also elsewhere on the board
/3V3D: C18.1, C170.1, C171.1, C194.1, C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, C201.1, C202.1, C203.1, C204.1, C251.1, C252.1, CON1.4 (VDD), P3.2, P4.2, R69.1, R110.1, R111.1, R112.1, R117.1, R118.1, U30.A6 (VCCO_35), U30.A16 (VCCO_15), U30.B3 (VCCO_35), U30.B13 (VCCO_15), U30.C10 (VCCO_15), U30.D7 (VCCO_35), U30.E4 (VCCO_35), U30.E7 (CFGBVS_0), U30.E14 (VCCO_15), U30.F1 (VCCO_35), U30.H15 (VCCO_15), U30.J2 (VCCO_35), U30.J12 (VCCO_15), U30.L6 (VCCO_0), U30.L16 (VCCO_14), U30.M3 (VCCO_34), U30.M13 (VCCO_14), U30.N10 (VCCO_14), U30.P7 (VCCO_14), U30.R4 (VCCO_34), U30.R14 (VCCO_14), U30.T1 (VCCO_34), U30.T11 (VCCO_14), U40.3 (~WP~(IO2)), U40.7 (~HOLD~(IO3)), U40.8 (VCC); also elsewhere on the board
/ADC_CE: U30.R3 (IO_L8P_T1_34); also elsewhere on the board
/ADF_CLK: R130.2; also elsewhere on the board
/ADF_DATA: U30.M2 (IO_L2P_T0_34); also elsewhere on the board
/ADF_LE: U30.N1 (IO_L4P_T0_34); also elsewhere on the board
/ADF_MUXOUT: Q2.1 (G), U30.K3 (IO_L24P_T3_35); also elsewhere on the board
/ADF_TXDATA: U30.P3 (IO_L5N_T0_34); also elsewhere on the board
/FPGA_REF: U30.N11 (IO_L13P_T2_MRCC_14); also elsewhere on the board
/MIX_ENBL: U30.J4 (IO_L19N_T3_VREF_35); also elsewhere on the board
/PA_OFF: U30.T2 (IO_L8N_T1_34); also elsewhere on the board
/fpga/ADC_OE1: U30.B2 (IO_L8P_T1_AD14P_35); also elsewhere on the board
/fpga/ADC_OE2: U30.P1 (IO_L4N_T0_34); also elsewhere on the board
/fpga/ADC_SHDN1: U30.B1 (IO_L9N_T1_DQS_AD7N_35); also elsewhere on the board
/fpga/ADC_SHDN2: U30.N2 (IO_L3N_T0_DQS_34); also elsewhere on the board
/fpga/ADF_DONE: C174.1, Q2.3 (D), U30.T4 (IO_L9P_T1_DQS_34)
/fpga/CARD_DETECT: CON1.9 (CARD_DETECT1), U30.H16 (IO_L22P_T3_A17_15)
/fpga/CCLK: P10.1, U30.E8 (CCLK_0), U40.6 (CLK)
/fpga/CLKOUT: U30.A15 (IO_L9N_T1_DQS_AD3N_15); also elsewhere on the board
/fpga/D0: U30.L2 (IO_L23N_T3_35); also elsewhere on the board
/fpga/D1: U30.K2 (IO_L24N_T3_35); also elsewhere on the board
/fpga/D2: U30.K1 (IO_L22P_T3_35); also elsewhere on the board
/fpga/D3: U30.J3 (IO_L21P_T3_DQS_35); also elsewhere on the board
/fpga/D4: U30.H1 (IO_L20N_T3_35); also elsewhere on the board
/fpga/D5: U30.H2 (IO_L20P_T3_35); also elsewhere on the board
/fpga/D6: U30.H3 (IO_L21N_T3_DQS_35); also elsewhere on the board
/fpga/D7: U30.G2 (IO_L17P_T2_35); also elsewhere on the board
/fpga/D8: U30.G1 (IO_L17N_T2_35); also elsewhere on the board
/fpga/D9: U30.F2 (IO_L15P_T2_DQS_35); also elsewhere on the board
/fpga/D10: U30.E1 (IO_L15N_T2_DQS_35); also elsewhere on the board
/fpga/D11: U30.E2 (IO_L10P_T1_AD15P_35); also elsewhere on the board
/fpga/EXT1_1: P4.3, U30.C11 (IO_L11P_T1_SRCC_15)
/fpga/EXT1_2: P4.5, U30.B10 (IO_L4P_T0_15)
/fpga/EXT1_3: P4.7, U30.A9 (IO_L2N_T0_AD8N_15)
/fpga/EXT1_4: P4.4, U30.C12 (IO_L11N_T1_SRCC_15)
/fpga/EXT1_5: P4.6, U30.B9 (IO_L3P_T0_DQS_AD1P_15)
/fpga/EXT1_6: P4.8, U30.A8 (IO_L2P_T0_AD8P_15)
/fpga/EXT2_1: P3.3, U30.B7 (IO_L1P_T0_AD4P_35)
/fpga/EXT2_2: P3.5, U30.A5 (IO_L3P_T0_DQS_AD5P_35)
/fpga/EXT2_3: P3.7, U30.A4 (IO_L3N_T0_DQS_AD5N_35)
/fpga/EXT2_4: P3.4, U30.A7 (IO_L1N_T0_AD4N_35)
/fpga/EXT2_5: P3.6, U30.B5 (IO_L2N_T0_AD12N_35)
/fpga/EXT2_6: P3.8, U30.A3 (IO_L4N_T0_35)
/fpga/FT_D0: U30.F15 (IO_L18P_T2_A24_15); also elsewhere on the board
/fpga/FT_D1: U30.G16 (IO_L22N_T3_A16_15); also elsewhere on the board
/fpga/FT_D2: U30.G15 (IO_L24N_T3_RS0_15); also elsewhere on the board
/fpga/FT_D3: U30.F14 (IO_L21N_T3_DQS_A18_15); also elsewhere on the board
/fpga/FT_D4: U30.E16 (IO_L17P_T2_A26_15); also elsewhere on the board
/fpga/FT_D5: U30.E15 (IO_L18N_T2_A23_15); also elsewhere on the board
/fpga/FT_D6: U30.D16 (IO_L17N_T2_A25_15); also elsewhere on the board
/fpga/FT_D7: U30.D15 (IO_L15N_T2_DQS_ADV_B_15); also elsewhere on the board
/fpga/FT_SUSPEND: U30.C16 (IO_L10P_T1_AD11P_15); also elsewhere on the board
/fpga/INIT_B: R117.2, U30.K10 (INIT_B_0)
/fpga/LED: R109.1, U30.D1 (IO_L10N_T1_AD15N_35)
/fpga/M0: R110.2, U30.M9 (M0_0)
/fpga/M1: R114.1, U30.M10 (M1_0)
/fpga/M2: R115.1, U30.M11 (M2_0)
/fpga/OE#: U30.A12 (IO_L5N_T0_AD9N_15); also elsewhere on the board
/fpga/OF1: U30.C2 (IO_L7N_T1_AD6N_35); also elsewhere on the board
/fpga/OF2: U30.M1 (IO_L2N_T0_34); also elsewhere on the board
/fpga/PROGRAM_B: R112.2, SW2.1, U30.L9 (PROGRAM_B_0)
/fpga/RD#: U30.B14 (IO_L8N_T1_AD10N_15); also elsewhere on the board
/fpga/RXF#: U30.B16 (IO_L10N_T1_AD11N_15); also elsewhere on the board
/fpga/SD_CLK: CON1.5 (CLK), U30.N14 (IO_L12P_T1_MRCC_14)
/fpga/SD_CMD: CON1.3 (CMD), U30.P16 (IO_L8N_T1_D12_14)
/fpga/SD_DAT0: CON1.7 (DAT0), U30.N16 (IO_L7N_T1_D10_14)
/fpga/SD_DAT1: CON1.8 (DAT1), U30.M16 (IO_L7P_T1_D09_14)
/fpga/SD_DAT2: CON1.1 (DAT2), U30.R16 (IO_L9N_T1_DQS_D13_14)
/fpga/SD_DAT3: CON1.2 (CD/DAT3), U30.R15 (IO_L9P_T1_DQS_14)
/fpga/SIWUA: U30.A13 (IO_L7P_T1_AD2P_15); also elsewhere on the board
/fpga/SPI_CS: R118.2, U30.L12 (IO_L6P_T0_FCS_B_14), U40.1 (~CS)
/fpga/SPI_DIN: P12.1, U30.J14 (IO_L1N_T0_D01_DIN_14), U40.2 (DO(IO1))
/fpga/SPI_MOSI: P11.1, U30.J13 (IO_L1P_T0_D00_MOSI_14), U40.5 (DI(IO0))
/fpga/TCK: P15.1, U30.L7 (TCK_0); also elsewhere on the board
/fpga/TDI: P13.1, U30.N7 (TDI_0); also elsewhere on the board
/fpga/TDO: P16.1, U30.N8 (TDO_0); also elsewhere on the board
/fpga/TMS: P14.1, U30.M7 (TMS_0); also elsewhere on the board
/fpga/TXE#: U30.B15 (IO_L9P_T1_DQS_AD3P_15); also elsewhere on the board
/fpga/WR: U30.A14 (IO_L7N_T1_AD2N_15); also elsewhere on the board
GND: C18.2, C170.2, C171.2, C174.2, C181.2, C182.2, C183.2, C184.2, C185.2, C186.2, C187.2, C188.2, C189.2, C190.2, C191.2, C192.2, C193.2, C194.2, C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C250.2, C251.2, C252.2, CON1.6 (VSS), CON1.10 (CARD_DETECT2), CON1.11 (SHELL), D6.1, P3.1, P4.1, Q2.2 (S), R70.2, R114.2, R115.2, SW2.2, U30.A1 (GND), U30.A11 (GND), U30.B8 (GND), U30.C5 (GND), U30.C15 (GND), U30.D2 (GND), U30.D12 (GND), U30.E9 (GND), U30.F6 (GND), U30.F8 (VCCBATT_0), U30.F10 (GND), U30.F16 (GND), U30.G3 (GND), U30.G7 (GNDADC_0), U30.G9 (GND), U30.G13 (GND), U30.H6 (GND), U30.H7 (VREFN_0), U30.J7 (VN_0), U30.J8 (VREFP_0), U30.J9 (GND), U30.J11 (GND), U30.K4 (GND), U30.K6 (GND), U30.K7 (DXN_0), U30.K8 (DXP_0), U30.K14 (GND), U30.L1 (GND), U30.L11 (GND), U30.M8 (GND), U30.N5 (GND), U30.N15 (GND), U30.P2 (GND), U30.P12 (GND), U30.R9 (GND), U30.T6 (GND), U30.T16 (GND)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; also elsewhere on the board
unnamed: D6.2, R109.2
unnamed: P6.1, U30.A2 (IO_L8N_T1_AD14N_35)
unnamed: P9.1, R111.2, U30.H10 (DONE_0)
unnamed: R69.2, R70.1, U30.L15 (IO_L3P_T0_DQS_PUDC_B_14)
unnamed: R130.1, U30.R1 (IO_L7N_T1_34)

Notes on the sheet:
VCCINT
VCCBRAM
VCCAUX
VCCO_0
VCCO
Internal reference
Quiescent current 1V0: 97 mA 1V8: 22 mA 3V3: 2 mA
Power-on current 1V0: Iq + 180 mA 1V8: Iq + 40 mA 3V3: Iq + 40 mA
Power supply ramp time: 0.2 ms - 50 ms
80 mA
TODO: Programming pins
Mode M[2:0] Master serial 000 Master SPI 001 Master BPI 010 Master SelectMap 100 JTAG 101 Slave SelectMap 110 Slave serial 111
70 mA
1 mA

Parts:
C2, C4, C6, C21, C32, C43, C176: 100n; C_0402b
C3, C5, C7, C8, C11, C36: 10p; C_0402b
C10: 2.2n; C_0402b
C14: 51p; C_0402b
C26, C38: 10u; C_0805b
C28: 10n; C_0402b
C29: 68p; C_0402b
C33, C34, C40, C41: 100p; C_0402b
C37: DNP; C_0603b
C39: 2.2u; C_0603b
C214, C215: DNP; C_0805b
FB2, FB3: BLM18PG181SN1D; C_0603b
FB4: CIC21P101NE; C_0805b
Q1: RE1C002UN; SOT-416
R1: 5.49k; R_0402b
R2, R40: DNP; R_0402b
R4: 3.1k; R_0402b
R5, R6, R7, R18: 4.7k; R_0402b
R9, R11, R12: 18; R_0402b
R10: 6.98k; R_0402b
R14: 39k; R_0402b
R17: 49.9; R_0402b
R39: 47k; R_0402b
U1: ADF4158; VFQFN-24
U3, U12: PAT1220-6dB; PAT1220
U7: TLV172DCK; SOT-353_SC-70-5
U10: HMC431LP4; VQFN-24
U14: MGA-25203
U15: SMA; CONSMA003.062
Z1: 15dB COUPLER; coupler

Connections:
/1V8: C176.1, R18.1; also elsewhere on the board
/3V0: FB3.1; also elsewhere on the board
/3V3A: C2.1, C3.1, C4.1, C5.1, C43.1, FB4.1, R10.2, R39.1, U1.6 (AVDD), U1.7 (AVDD), U1.8 (AVDD), U1.18 (SDVDD), U1.19 (DVDD); also elsewhere on the board
/5V: C214.2, C215.2, FB2.1; also elsewhere on the board
/10V: C21.1, U7.5 (V+); also elsewhere on the board
/ADC_CE: U1.13 (CE); also elsewhere on the board
/ADF_CLK: U1.14 (CLK); also elsewhere on the board
/ADF_DATA: U1.15 (DATA); also elsewhere on the board
/ADF_LE: U1.16 (LE); also elsewhere on the board
/ADF_MUXOUT: U1.17 (MUXOUT); also elsewhere on the board
/ADF_REF: U1.9 (REFIN); also elsewhere on the board
/ADF_TXDATA: U1.12 (TXDATA); also elsewhere on the board
/LO: U3.1; also elsewhere on the board
/PA_OFF: Q1.1 (G), R39.2, R40.1; also elsewhere on the board
/tx/BSW: C36.1, Q1.3 (D), R18.2, U14.6 (BSW)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C14.2, C21.2, C26.2, C28.2, C29.2, C32.2, C33.2, C34.2, C36.2, C37.1, C38.1, C39.1, C40.1, C41.1, C43.2, C176.2, C214.1, C215.1, Q1.2 (S), R1.2, R4.2, R5.2, R14.1, R17.1, R40.2, U1.1 (CPGND), U1.2 (AGND), U1.3 (AGND), U1.10 (DGND), U1.11 (SDGND), U1.PAD (EP), U3.3, U7.2 (V-), U10.15 (GND), U10.PAD, U12.3, U14.2 (GND), U14.3 (GND), U14.10 (GND), U14.12 (GND), U14.14 (GND), U14.16 (GND), U14.EP (GND), U15.2; also elsewhere on the board
unnamed: C6.1, C7.1, FB2.2, U1.22 (VP)
unnamed: C8.2, U1.4 (RFINB)
unnamed: C10.1, C14.1, U1.24 (CP), U7.1
unnamed: C10.2, R2.1, R4.1
unnamed: C11.1, R12.2
unnamed: C11.2, U1.5 (RFINA)
unnamed: C26.1, C28.1, FB3.2, U10.20 (VCC)
unnamed: C29.1, R7.1, U10.22 (VTUNE)
unnamed: C32.1, C33.1, C34.1, R10.1, R14.2, U14.4 (BCTRL)
unnamed: C37.2, C38.2, C39.2, C40.2, C41.2, FB4.2, U14.5 (BSPLY), U14.13 (VCC)
unnamed: R1.1, U1.23 (RSET)
unnamed: R2.2, U1.20 (SW1)
unnamed: R5.1, R6.2, U7.3
unnamed: R6.1, R7.2, U7.4
unnamed: R9.2, U10.16 (RFOUT)
unnamed: R11.1, U12.2
unnamed: R9.1, R11.2, R12.1
unnamed: R17.2, Z1.4
unnamed: U3.2, Z1.3
unnamed: U12.1, U14.1 (RFIN)
unnamed: U14.11 (RFOUT), Z1.1
unnamed: U15.1, Z1.2

Notes on the sheet:
Resistive splitter (-6 dBm)
+2 dBm output
-4 dBm
27mA
-7 dBm
Gain: 29 dB - 32 dB
19 - 22 dBm
35 mA
450 mA
1.8V
10V current: 1mA 3.3V current: 600mA 5V current: 1mA

Parts:
C35, C47, C50, C54: DNP; C_0603b
C42, C46: 18p; C_0402b
C44: 10p; C_0402b
C48: 0.5p; C_0402b
C49: 100n; C_0402b
C179: 10n; C_0402b
C180: 100p; C_0402b
FB7, FB8: BLM18PG181SN1D; C_0603b
L1: LQW15AN9N9J80D; C_0402b
L2: 0.6n; C_0402b
P1: SMA; CONSMA003.062
R22: 100; R_0402b
U9: TRF37A73; DFN-8-1EP_2x2mm_Pitch0.5mm
U11: SKY65404; XFDFN-6

Connections:
/3V0: C35.1, C47.1, FB7.1, FB8.1; also elsewhere on the board
/RF1: C42.2; also elsewhere on the board
GND: C35.2, C44.2, C47.2, C48.2, C49.2, C50.2, C54.2, C179.2, C180.2, P1.2, U9.3 (NC), U9.4 (NC), U9.5 (PWDN), U9.6 (NC), U9.8 (NC), U9.9 (GND), U11.2 (GND), U11.5 (GND), U11.PAD; also elsewhere on the board
unnamed: C42.1, L1.1, U9.7 (RFOUT)
unnamed: C46.1, U11.4 (RF_OUT)
unnamed: C46.2, U9.2 (RFIN)
unnamed: C48.1, P1.1, U11.3 (RF_IN)
unnamed: L2.1, U11.6 (VCC)
unnamed: R22.1, U11.1 (V_ENABLE)

Parts of its further copies:
C45, C51, C56, C59: DNP; C_0603b
C52, C55: 18p; C_0402b
C53: 10p; C_0402b
C57: 0.5p; C_0402b
C58: 100n; C_0402b
C206: 10n; C_0402b
C213: 100p; C_0402b
FB5, FB6: BLM18PG181SN1D; C_0603b
L3: LQW15AN9N9J80D; C_0402b
L4: 0.6n; C_0402b
P2: SMA; CONSMA003.062
R23: 100; R_0402b
U13: TRF37A73; DFN-8-1EP_2x2mm_Pitch0.5mm
U16: SKY65404; XFDFN-6

Connections of its further copies:
/3V0: C51.1, C56.1, FB5.1, FB6.1; also elsewhere on the board
/RF2: C52.2; also elsewhere on the board
GND: C45.2, C51.2, C53.2, C56.2, C57.2, C58.2, C59.2, C206.2, C213.2, P2.2, U13.3 (NC), U13.4 (NC), U13.5 (PWDN), U13.6 (NC), U13.8 (NC), U13.9 (GND), U16.2 (GND), U16.5 (GND), U16.PAD; also elsewhere on the board
unnamed: C52.1, L3.1, U13.7 (RFOUT)
unnamed: C55.1, U16.4 (RF_OUT)
unnamed: C55.2, U13.2 (RFIN)
unnamed: C57.1, P2.1, U16.3 (RF_IN)
unnamed: L4.1, U16.6 (VCC)
unnamed: R23.1, U16.1 (V_ENABLE)

Notes on the sheet:
55 mA
15 mA
Gain: 13 dB NF: 1.0 dB IP1dB: -4 dBm
Gain: 11 dB NF: 5.5 dB IP1dB: -3 dBm
Gain: 26 dB IP1dB: -16 dBm

Parts:
C60, C61, C62, C64, C70, C76, C77, C78, C79, C80, C82, C83, C84, C85, C86, C87, C88, C93, C94, C98, C100, C101, C102, C106: 10u; C_0805b
C63, C65, C66, C95, C96, C97, C99: 10n; C_0402b
C67: 39p; C_0402b
C68: 100p; C_0402b
C69: 68p; C_0402b
C71, C72, C81, C103, C104, C105, C169, C172, C177, C178: DNP; C_0805b
C73: 15n; C_0402b
C74: 8.2n; C_0402b
C75: 4.7n; C_0402b
C89: 1u; C_0603b
C90, C91, C92: 100n; C_0402b
C175: DNP; C_0402b
CON2: Barrel_Jack; EJ508A
D1: LED; LED_0603
D2, D3, D4: SS13FL; SOD-123F
FB11: CIC21P101NE; C_0805b
L5, L6, L7: 33u (SRR6040A-330M); SRR6040A
R24: 240; R_0402b
R25, R26, R104: 68k; R_0402b
R27: 15k; R_0402b
R28: 59k; R_0402b
R29: 6.8k; R_0402b
R30: 8.2k; R_0402b
R31, R101: DNP; R_0402b
R32, R34, R36: 4.99k; R_0402b
R33: 7.5k; R_0402b
R35: 1k; R_0402b
R37: 590; R_0402b
R38: 33; R_0402b
R41: 56; R_0402b
R42: 100; R_0402b
R43: 10.5k; R_0402b
R44: 2k; R_0402b
R45: 1.87k; R_0402b
R46: 1.5k; R_0402b
R47: 3.57k; R_0402b
R48: 1.15k; R_0402b
R103: 0; R_0402b
U17, U18, U19: L7980; DFN-8-1EP_3x3mm_P0.5mm_EP1.66x2.38mm
U20: LP5907-3.0; SOT-23-5
U21: LP2985A-10DBVR; SOT-23-5
U22, U23, U24: TPS7A91; SON-10_2.5x2.5mm
U25: MIC5301-3.3; SOT-23-5

Connections:
/1V0: C76.1, C78.1, L5.2, R32.1, R38.1; also elsewhere on the board
/1V8: C97.1, C101.1, C104.1, R45.1, U23.1 (OUT), U23.2 (OUT); also elsewhere on the board
/3V0: C93.1, C172.1, U20.5 (OUT); also elsewhere on the board
/3V3A: C99.1, C102.1, C105.1, R47.1, U24.1 (OUT), U24.2 (OUT); also elsewhere on the board
/3V3D: C106.1, U25.5 (VOUT); also elsewhere on the board
/3V6: C77.1, C80.1, C81.1, C85.1, C87.1, C88.1, C94.1, L6.2, R24.1, R34.1, R41.1, R104.1, U20.1 (IN), U20.3 (EN), U23.6 (SS_CTRL), U23.9 (IN), U23.10 (IN), U24.6 (SS_CTRL), U24.7 (EN), U24.9 (IN), U24.10 (IN), U25.1 (VIN); also elsewhere on the board
/5V: C96.1, C100.1, C103.1, R43.1, U22.1 (OUT), U22.2 (OUT); also elsewhere on the board
/10V: C98.1, U21.5 (VOUT); also elsewhere on the board
/power/5V6: C79.1, C82.1, C83.1, C84.1, C86.1, C169.1, L7.2, R36.1, R42.1, R101.2, U22.6 (SS_CTRL), U22.7 (EN), U22.9 (IN), U22.10 (IN), U23.7 (EN)
/power/12V: C60.1, C61.1, C62.1, C70.1, C71.1, C72.1, C89.1, C177.1, C178.1, FB11.2, R103.2, U17.8 (VCC), U18.3 (EN), U18.8 (VCC), U19.3 (EN), U19.8 (VCC), U21.1 (VIN), U21.3 (ON/~OFF~)
/power/SYNC: R31.1, U18.2 (SYNCH), U19.2 (SYNCH)
GND: C60.2, C61.2, C62.2, C64.2, C70.2, C71.2, C72.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C98.2, C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C169.2, C172.2, C175.2, C177.2, C178.2, CON2.2, CON2.3, D1.1, D2.2 (A), D3.2 (A), D4.2 (A), R25.2, R26.2, R28.2, R33.2, R35.2, R37.2, R44.2, R46.2, R48.2, U17.7 (GND), U17.9 (EP), U18.7 (GND), U18.9 (EP), U19.7 (GND), U19.9 (EP), U20.2 (GND), U21.2 (GND), U22.4 (GND), U22.11 (PAD), U23.4 (GND), U23.11 (PAD), U24.4 (GND), U24.11 (PAD), U25.2 (GND); also elsewhere on the board
unnamed: C63.1, R27.2
unnamed: C63.2, C67.2, C73.2, R32.2, R33.1, U17.5 (FB)
unnamed: C64.1, CON2.1, FB11.1
unnamed: C65.1, R29.2
unnamed: C65.2, C68.2, C74.2, R34.2, R35.1, U18.5 (FB)
unnamed: C66.1, R30.2
unnamed: C66.2, C69.2, C75.2, R36.2, R37.1, U19.5 (FB)
unnamed: C67.1, R27.1, U17.4 (COMP)
unnamed: C68.1, R29.1, U18.4 (COMP)
unnamed: C69.1, R30.1, U19.4 (COMP)
unnamed: C73.1, R38.2
unnamed: C74.1, R41.2
unnamed: C75.1, R42.2
unnamed: C90.1, U22.8 (NR/SS)
unnamed: C91.1, U23.8 (NR/SS)
unnamed: C92.1, U24.8 (NR/SS)
unnamed: C95.1, U21.4 (BYPASS)
unnamed: C96.2, R43.2, R44.1, U22.3 (FB)
unnamed: C97.2, R45.2, R46.1, U23.3 (FB)
unnamed: C99.2, R47.2, R48.1, U24.3 (FB)
unnamed: C175.1, U25.4 (BYP)
unnamed: D1.2, R24.2
unnamed: D2.1 (K), L5.1, U17.1 (OUT)
unnamed: D3.1 (K), L6.1, U18.1 (OUT)
unnamed: D4.1 (K), L7.1, U19.1 (OUT)
unnamed: R25.1, U17.6 (FSW)
unnamed: R26.1, U18.6 (FSW)
unnamed: R28.1, U19.6 (FSW)
unnamed: R31.2, U17.2 (SYNCH)
unnamed: R101.1, R103.1, U17.3 (EN)
unnamed: R104.2, U23.5 (PG), U25.3 (EN)

Parts:
C107: DNP; C_0805b
C108, C115, C116, C120, C121, C122, C123: 100n; C_0402b
C109, C110, C111, C112, C113, C114: 10p; C_0402b
C117, C118, C119: 100p; C_0402b
C162: 10u; C_0805b
F1, F2: Via; RF_via
FB13: BLM18PG181SN1D; C_0603b
R49: 2k; R_0402b
R50: DNP; R_0402b
R51, R52, R53, R54: 49.9; R_0402b
U26, U27, U28: 5400BL15B050E
U29: ADL5802; QFN-24-1EP_4x4mm_Pitch0.5mm

Connections:
/5V: C107.2, FB13.1; also elsewhere on the board
/LO: F1.1, F2.1, U26.1 (IN); also elsewhere on the board
/MIX_ENBL: U29.7 (ENBL); also elsewhere on the board
/RF1: U27.1 (IN); also elsewhere on the board
/RF2: U28.1 (IN); also elsewhere on the board
/if/IF1+: R52.2, U29.4 (OP1-); also elsewhere on the board
/if/IF1-: R51.1, U29.3 (OP1+); also elsewhere on the board
/if/IF2+: R54.2, U29.16 (OP2+); also elsewhere on the board
/if/IF2-: R53.1, U29.15 (OP2-); also elsewhere on the board
/mixer/5VF: C108.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C162.2, FB13.2, R49.1, R51.2, R52.1, R53.2, R54.1, U29.6 (VPOS), U29.13 (VPOS), U29.24 (VPOS)
GND: C107.1, C108.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C162.1, F1.2, F2.2, R50.2, U26.2 (GND), U26.5 (GND), U27.2 (GND), U27.5 (GND), U28.2 (GND), U28.5 (GND), U29.1 (GND), U29.2 (GND), U29.5 (GND), U29.8 (GND), U29.11 (GND), U29.14 (GND), U29.17 (GND), U29.18 (GND), U29.21 (GND), U29.25 (GND); also elsewhere on the board
unnamed: C109.1, U29.9 (LOIP)
unnamed: C109.2, U26.4 (OUTN)
unnamed: C110.1, U29.10 (LOIN)
unnamed: C110.2, U26.3 (OUTP)
unnamed: C111.1, U29.19 (RF2-)
unnamed: C111.2, U27.4 (OUTN)
unnamed: C112.1, U29.20 (RF2+)
unnamed: C112.2, U27.3 (OUTP)
unnamed: C113.1, U29.22 (RF1-)
unnamed: C113.2, U28.4 (OUTN)
unnamed: C114.1, U29.23 (RF1+)
unnamed: C114.2, U28.3 (OUTP)
unnamed: R49.2, R50.1, U29.12 (VSET)

Notes on the sheet:
300 mA
